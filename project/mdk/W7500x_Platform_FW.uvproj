# Keil uVision project W7500x_Platform_FW.uvproj, settings and files
target W7500x_Platform (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W7500x_S2E_App +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\..\lib\W7500x_stdPeriph_Driver\inc;..\..\lib\CMSIS\Include;..\..\lib\CMSIS\Device\WIZnet\W7500\Include;..\..\src;..\..\lib\ioLibrary\Ethernet;..\..\lib\ioLibrary\Internet\DHCP;..\..\lib\ioLibrary\Internet\DNS;..\..\lib\ioLibrary\MDIO;..\..\src\hw\core;..\..\src\testSuite;..\..\src\common;..\..\src\app;..\..\src\hw;..\..\src\hw\board
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../../lib/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group CMSIS
    ../../lib/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group W7500_Periphs
    ../../lib/W7500x_stdPeriph_Driver/src/: W7500x_adc.c W7500x_crg.c W7500x_dma.c W7500x_dualtimer.c W7500x_exti.c W7500x_gpio.c W7500x_pwm.c W7500x_rng.c W7500x_ssp.c W7500x_uart.c W7500x_wdt.c W7500x_wztoe.c
  group ioLibrary
    ../../lib/ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../../lib/ioLibrary/Internet/DHCP/: dhcp.c
    ../../lib/ioLibrary/Internet/DNS/: dns.c
    ../../lib/ioLibrary/MDIO/: W7500x_miim.c
  group userMain
    ../../src/: main.c printf_retarget.c
  group platformHandler
    ../../src/hw/core/: adcHandler.c crgHandler.c dmaHandler.c ex_uartHandler.c extiHandler.c flashHandler.c gpioHandler.c pwmHandler.c rngHandler.c softi2cHandler.c sspHandler.c timerHandler.c uartHandler.c wdtHandler.c wztoeHandler.c
  group testSuite
    ../../src/testSuite/flash/: flashTest.c
    ../../src/testSuite/softI2C/: softI2CTest.c
    ../../src/testSuite/uart/: uartTest.c
    ../../src/testSuite/: testSuite.c
    ../../src/testSuite/gpio/: gpioTest.c
  group board
    ../../src/hw/board/: board.c phy.c
  group app
    ../../src/app/: app.c
  group hw
    ../../src/hw/: hw.c W7500x_it.c
